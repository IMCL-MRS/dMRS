# IAR project STM32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xE ST STM32F100xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: VECT_TAB_FLASH; STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ../STM32F10x_StdPeriph_Driver/inc; ../CMSIS/CM3/CoreSupport/ST/STM32F10x; ../CMSIS/CM3/DeviceSupport/ST/STM32F10x; ../User/inc; ../App/inc; ../FreeRTOSV7.2.0/include; ../FreeRTOSV7.2.0/portable/IAR/ARM_CM3; ../HalDriver/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../STM32F10x_StdPeriph_Driver/inc; ../CMSIS/Core/CM3; ../User/inc; ../FreeRTOSV7.2.0/include; ../FreeRTOSV7.2.0/portable/IAR/ARM_CM3
  OBJCOPY.OOCOutputFile: STM32.srec
  ILINK.IlinkOutputFile: STM32.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP/inc
    ../APP/inc/: apps.h vBCastTask.h vDemoTask.h vInfoList.h vMagTask.h vRadioTask.h vTestCase.h
  group APP/src
    ../APP/src/: vBCastTask.c vBeepTask.c vDemoTask.c vMagTask.c vRadioTask.c vTestCase.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../车载称重/汉德科技/软件/显示/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group CMSIS/startUp
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group FreeRTOSV7.2.0
    ../FreeRTOSV7.2.0/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOSV7.2.0/include
    ../FreeRTOSV7.2.0/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOSV7.2.0/portable/IAR
    ../FreeRTOSV7.2.0/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group FreeRTOSV7.2.0/portable/MemMang
    ../FreeRTOSV7.2.0/portable/MemMang/: heap_2.c
  group HalDriver/inc
    ../HalDriver/inc/: hal24LC02B.h halADC12.h halBeep.h halButton.h halI2C.h halI2S.h halInfrared.h halLed.h halMCUWait.h halMPU9250.h halnRF24L01P.h halSPI.h halTIM3.h halUltraSound.h
  group HalDriver/src
    ../HalDriver/src/: hal24LC02B.c halADC12.c halBeep.c halButton.c halI2C.c halI2S.c halInfrared.c halLed.c halMCUWait.c halMPU9250.c halnRF24L01P.c halSPI.c halTIM3.c halUltraSound.c
  group STM32F10x_StdPeriph_Driver/inc
    ../STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group STM32F10x_StdPeriph_Driver/src
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User/inc
    ../User/inc/: basicMotion.h bottomBoard.h CRC16.h CRC8.h FreeRTOSConfig.h intMath.h mrslib.h posSystem.h radio.h readMPUSensor.h stm32f10x_conf.h stm32f10x_it.h systemConfig.h ultraSound.h
  group User/src
    ../User/src/: basicMotion.c bottomBoard.c CRC16.c CRC8.c intMath.c main.c posSystem.c radio.c readMPUSensor.c stm32f10x_it.c ultraSound.c
